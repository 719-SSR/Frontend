Commit message: Modlues

File: vendor/three.js-r161/examples/models/urdf3/claude.urdf (robot description, URDF)
Before this commit: robot underwater_robot, 8 links, 7 joints
Links:
- link cone: geometry collision mesh filename=cone.stl; visual mesh filename=cone.stl
